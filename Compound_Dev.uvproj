# Keil uVision project Compound_Dev.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Compound_Dev +hex
  c flags: Optimize=6 SizeSpeed=1
  c include: .\hal_driver
  group Source Group 1
    ./: Compound.C main.c README.TXT
    ./Public/: DEBUG.C
  group hal_driver
    ./hal_driver/: key.c key.h
